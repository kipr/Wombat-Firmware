# Repository kipr/Wombat-Firmware (continued)

## EAGLE design docs/botball_v5.brd (continued)

Schematic: botball_v5.sch, sheet 36

Parts:
BOOT0: DNP; TP0500
C121, C122: 22pF; 0402
C123, C125, C126, C127, C128, C129, C130, C138: 0.1uF; 0201
C124, C137: 4.7uF; 0603
C131, C133: 1.0uF; 0402
C132, C134: 0.01uF; 0201
C135, C136: 2.2uF; 0603
FB9: 120R 1A; 0402
IC3: STM32F10XVXT6-FLASH; TQFP100
JTAG: DNP; 1365-10
R63, R111, R136, R137: DNP; 0603
R83: 240R0; 0201
R84: 33R0; 0201
R85: 100K; 0402
R86, R89, R91: 10K; 0201
R87, R90: 0R; 0201
R88, R92: 100K; 0201
U31: EVQKMT0; KMT0
VCC1: DNP; TP0500
Y2: 24.000MHz; CRYSTAL-3225

Connections:
4.VCC_BATT: R88.1; also elsewhere on the board
18.VCC_3.3: C124.1, C125.1, C126.1, C127.1, C128.1, C129.1, C130.1, C137.1, C138.1, FB9.2, IC3.11 (VDD_5), IC3.19 (VSSA_OR_VDD), IC3.28 (VDD_4), IC3.50 (VDD_1), IC3.75 (VDD_2), IC3.100 (VDD_3), JTAG.1, R63.2, R90.1, R92.1, R111.2, R136.2, R137.2, U31.1 (A), U31.2 (A'), VCC1.1; also elsewhere on the board
39.ADC12_IN4: IC3.29 (PA4); also elsewhere on the board
39.ADC12_IN5: IC3.30 (PA5); also elsewhere on the board
39.ADC12_IN6: IC3.31 (PA6); also elsewhere on the board
39.ADC12_IN7: IC3.32 (PA7); also elsewhere on the board
39.ADC12_IN9: IC3.36 (PB1); also elsewhere on the board
39.ADC12_IN14: IC3.33 (PC4); also elsewhere on the board
39.ADC12_IN15: IC3.34 (PC5); also elsewhere on the board
39.ADC123_IN0: IC3.23 (PA0); also elsewhere on the board
39.ADC123_IN1: IC3.24 (PA1); also elsewhere on the board
39.ADC123_IN2: IC3.25 (PA2); also elsewhere on the board
39.ADC123_IN3: IC3.26 (PA3); also elsewhere on the board
39.ADC123_IN11: IC3.16 (PC1); also elsewhere on the board
39.ADC123_IN12: IC3.17 (PC2); also elsewhere on the board
39.ADC123_IN13: IC3.18 (PC3); also elsewhere on the board
39.AGND: C133.2, C134.2, IC3.20 (VSSA_OR_VREF-), R87.1; also elsewhere on the board
39.BOOT0: BOOT0.1, IC3.94 (BOOT0), R85.1, R91.2; also elsewhere on the board
39.I2C1_SCL: IC3.92 (PB6); also elsewhere on the board
39.I2C1_SDA: IC3.93 (PB7); also elsewhere on the board
39.PB0: IC3.35 (PB0); also elsewhere on the board
39.PB8: IC3.95 (PB8); also elsewhere on the board
39.PB9: IC3.96 (PB9); also elsewhere on the board
39.PC9: IC3.66 (PC9); also elsewhere on the board
39.PC13: IC3.7 (PC13); also elsewhere on the board
39.PC14: IC3.8 (PC14); also elsewhere on the board
39.PC15: IC3.9 (PC15); also elsewhere on the board
39.PD0: IC3.81 (PD0); also elsewhere on the board
39.PD1: IC3.82 (PD1); also elsewhere on the board
39.PD2: IC3.83 (PD2); also elsewhere on the board
39.PD3: IC3.84 (PD3); also elsewhere on the board
39.PD4: IC3.85 (PD4); also elsewhere on the board
39.PD7: IC3.88 (PD7); also elsewhere on the board
39.PD8: IC3.55 (PD8); also elsewhere on the board
39.PD9: IC3.56 (PD9); also elsewhere on the board
39.PD10: IC3.57 (PD10); also elsewhere on the board
39.PD11: IC3.58 (PD11); also elsewhere on the board
39.PD12: IC3.59 (PD12); also elsewhere on the board
39.PD13: IC3.60 (PD13); also elsewhere on the board
39.PD14: IC3.61 (PD14); also elsewhere on the board
39.PD15: IC3.62 (PD15); also elsewhere on the board
39.PE0: IC3.97 (PE0); also elsewhere on the board
39.PE1: IC3.98 (PE1); also elsewhere on the board
39.PE4: IC3.3 (PE4); also elsewhere on the board
39.PE9: IC3.40 (PE9); also elsewhere on the board
39.PE11: IC3.42 (PE11); also elsewhere on the board
39.PE15: IC3.46 (PE15); also elsewhere on the board
39.PWM1: IC3.67 (PA8); also elsewhere on the board
39.PWM2: IC3.68 (PA9), R92.2; also elsewhere on the board
39.PWM3: IC3.69 (PA10); also elsewhere on the board
39.PWM4: IC3.63 (PC6); also elsewhere on the board
39.PWM5: IC3.64 (PC7); also elsewhere on the board
39.PWM6: IC3.65 (PC8); also elsewhere on the board
39.PWM7: IC3.4 (PE5); also elsewhere on the board
39.PWM8: IC3.5 (PE6); also elsewhere on the board
39.SPI2_CLK: IC3.52 (PB13); also elsewhere on the board
39.SPI2_CS0: IC3.51 (PB12); also elsewhere on the board
39.SPI2_MISO: IC3.53 (PB14); also elsewhere on the board
39.SPI2_MOSI: IC3.54 (PB15); also elsewhere on the board
39.SPI3_CLK: IC3.78 (PC10); also elsewhere on the board
39.SPI3_CS0: IC3.1 (PE2); also elsewhere on the board
39.SPI3_CS1: IC3.2 (PE3); also elsewhere on the board
39.SPI3_MISO: IC3.79 (PC11); also elsewhere on the board
39.SPI3_MOSI: IC3.80 (PC12); also elsewhere on the board
39.SPI4_CLK: IC3.43 (PE12); also elsewhere on the board
39.SPI4_MISO: IC3.44 (PE13); also elsewhere on the board
39.SPI4_MOSI: IC3.45 (PE14); also elsewhere on the board
39.STM_RESET: C123.1, IC3.14 (NRST), JTAG.10; also elsewhere on the board
39.UART2_RX: IC3.87 (PD6); also elsewhere on the board
39.UART2_TX: IC3.86 (PD5); also elsewhere on the board
39.UART3_RX: IC3.48 (PB11); also elsewhere on the board
39.UART3_TX: IC3.47 (PB10); also elsewhere on the board
39.USB_DEVICE_N: IC3.70 (PA11); also elsewhere on the board
39.USB_DEVICE_P: IC3.71 (PA12); also elsewhere on the board
ADC123_IN10$39: IC3.15 (PC0), R88.2, R89.1
BOOT0_VCC$39: R91.1, U31.3 (B), U31.4 (B')
BOOT1$39: IC3.37 (PB2), R86.2
GND: C121.2, C122.2, C123.2, C124.2, C125.2, C126.2, C127.2, C128.2, C129.2, C130.2, C131.2, C132.2, C135.2, C136.2, C137.2, C138.2, IC3.10 (VSS_5), IC3.27 (VSS_4), IC3.74 (VSS_2), IC3.99 (VSS_3), JTAG.3, JTAG.5, JTAG.9, R85.2, R86.1, R87.2, R89.2, Y2.2, Y2.4; also elsewhere on the board
LM3S_OSC0$39: IC3.13 (OSC_OUT), R83.1
STM_OSC1$39: C122.1, IC3.12 (OSC_IN), Y2.3
STM_OSC2$39: C121.1, R83.2, Y2.1
TCK$39: IC3.76 (PA14), JTAG.4, R111.1
TDI$39: IC3.77 (PA15), JTAG.8, R137.1
TDO$39: IC3.89 (PB3), JTAG.6, R136.1
TMS$39: IC3.72 (PA13), JTAG.2, R63.1
VBAT$39: IC3.6 (VBAT), R90.2
VCAP_1$39: C135.1, IC3.49 (VCAP_1)
VCAP_2$39: C136.1, IC3.73 (VCAP_2)
VDDA$39: C133.1, C134.1, FB9.1, IC3.22 (VDDA), R84.2
VREFP$39: C131.1, C132.1, IC3.21 (VREF+), R84.1

Notes on the sheet:
M4 Microprocessor [MOD00069] (39)

Schematic: botball_v5.sch, sheet 37

Parts:
C139, C140: 0.1uF; 0201
C141: 1.0uF; 0201
R93, R94: DNP; 0201
U32: TXS0102; DFN8-0.4P

Connections:
17.VCC_1.8: C139.1, U32.1 (VCCA), U32.5 (OE); also elsewhere on the board
18.VCC_3.3: C140.1, C141.1, U32.8 (VCCB); also elsewhere on the board
39.BOOT0: R93.2, U32.7 (B1); also elsewhere on the board
39.STM_RESET: R94.2, U32.6 (B2); also elsewhere on the board
45.GPIO1_1: R93.1, U32.2 (A1); also elsewhere on the board
45.GPIO1_2: R94.1, U32.3 (A2); also elsewhere on the board
GND: C139.2, C140.2, C141.2, U32.4 (GND); also elsewhere on the board

Notes on the sheet:
GPIO Bridge [MOD00136] (40)
GPIO ============================================= If input and output logic levels are both 3.3V set C1, C2 and U1 to DNP and R2 and R2 to 0R. VCCB >= VCCA

Schematic: botball_v5.sch, sheet 38

Parts:
C144, C145, C146, C147, C148, C149, C150, C151, C152: 0.1uF; 0201
R95: 75K; 0402
U$66: ADS7846RGV; QFN16
U$67, U$68, U$69: SN74LVC16T245; TVSOP48
U$70: FH12-40-NHD-4.3; FH12-40S-0.5SH

Connections:
3V_DISPLAY_EN$43: U$67.38 (1A6), U$70.31 (DISP)
3V_L_BIAS$43: U$67.43 (1A3), U$70.34 (DE)
3V_L_FCLK$43: U$67.41 (1A4), U$70.33 (VSYNC)
3V_L_LCLK$43: U$67.40 (1A5), U$70.32 (HSYNC)
3V_L_PCLK$43: U$67.37 (1A7), U$70.30 (PCLK)
3V_MISO$43: U$66.16 (DOUT), U$69.41 (1A4)
3V_MOSI$43: U$66.2 (DIN), U$67.44 (1A2)
3V_NPENIRQ$43: R95.2, U$66.15 (NPENIRQ), U$69.38 (1A6)
3V_SPI_CLK$43: U$66.4 (DCLK), U$67.47 (1A0)
3V_TS_BUSY$43: U$66.1 (BUSY)
17.VCC_1.8: C149.1, C150.1, C152.1, U$67.7 (VCCB), U$67.18 (VCCB), U$68.7 (VCCB), U$68.18 (VCCB), U$69.7 (VCCB), U$69.18 (VCCB); also elsewhere on the board
18.VCC_3.3: C144.1, C146.1, C147.1, C148.1, C151.1, R95.1, U$66.5 (VCC), U$66.14 (VCC), U$67.31 (VCCA), U$67.42 (VCCA), U$68.31 (VCCA), U$68.42 (VCCA), U$69.1 (1DIR), U$69.31 (VCCA), U$69.42 (VCCA), U$70.4 (VDD); also elsewhere on the board
45.BACKLIGHT_ENABLE: U$67.11 (1B6); also elsewhere on the board
45.BACKLIGHT_N: U$70.1 (LED-); also elsewhere on the board
45.BACKLIGHT_P: U$70.2 (LED+); also elsewhere on the board
45.GPIO0_7: U$69.11 (1B6); also elsewhere on the board
45.LCD_BIAS: U$67.6 (1B3); also elsewhere on the board
45.LCD_DD0: U$68.19 (2B4); also elsewhere on the board
45.LCD_DD1: U$68.17 (2B3); also elsewhere on the board
45.LCD_DD2: U$68.16 (2B2); also elsewhere on the board
45.LCD_DD3: U$68.14 (2B1); also elsewhere on the board
45.LCD_DD4: U$68.13 (2B0); also elsewhere on the board
45.LCD_DD5: U$68.9 (1B5); also elsewhere on the board
45.LCD_DD6: U$68.8 (1B4); also elsewhere on the board
45.LCD_DD7: U$68.6 (1B3); also elsewhere on the board
45.LCD_DD8: U$68.5 (1B2); also elsewhere on the board
45.LCD_DD9: U$68.3 (1B1); also elsewhere on the board
45.LCD_DD10: U$68.2 (1B0); also elsewhere on the board
45.LCD_DD11: U$67.19 (2B4); also elsewhere on the board
45.LCD_DD12: U$67.17 (2B3); also elsewhere on the board
45.LCD_DD13: U$67.16 (2B2); also elsewhere on the board
45.LCD_DD14: U$67.14 (2B1); also elsewhere on the board
45.LCD_DD15: U$67.13 (2B0); also elsewhere on the board
45.LCD_DD16: U$68.20 (2B5); also elsewhere on the board
45.LCD_DD17: U$67.20 (2B5); also elsewhere on the board
45.LCD_DD18: U$68.22 (2B6); also elsewhere on the board
45.LCD_DD19: U$68.11 (1B6); also elsewhere on the board
45.LCD_DD20: U$67.22 (2B6); also elsewhere on the board
45.LCD_DD21: U$68.23 (2B7); also elsewhere on the board
45.LCD_DD22: U$68.12 (1B7); also elsewhere on the board
45.LCD_DD23: U$67.23 (2B7); also elsewhere on the board
45.LCD_HSYNC: U$67.9 (1B5); also elsewhere on the board
45.LCD_PCLK: U$67.12 (1B7); also elsewhere on the board
45.LCD_VSYNC: U$67.8 (1B4); also elsewhere on the board
45.SPI0_CLK: U$67.2 (1B0); also elsewhere on the board
45.SPI0_CS0: U$67.3 (1B1); also elsewhere on the board
45.SPI0_MISO: U$69.8 (1B4); also elsewhere on the board
45.SPI0_MOSI: U$67.5 (1B2); also elsewhere on the board
!3V_SPI_TS_CS$43: U$66.3 (!CS), U$67.46 (1A1)
BLUE0$43: U$67.26 (2A7), U$70.21 (B0)
BLUE1$43: U$67.27 (2A6), U$70.22 (B1)
BLUE2$43: U$67.29 (2A5), U$70.23 (B2)
BLUE3$43: U$67.30 (2A4), U$70.24 (B3)
BLUE4$43: U$67.32 (2A3), U$70.25 (B4)
BLUE5$43: U$67.33 (2A2), U$70.26 (B5)
BLUE6$43: U$67.35 (2A1), U$70.27 (B6)
BLUE7$43: U$67.36 (2A0), U$70.28 (B7)
GND: C144.2, C145.2, C146.2, C147.2, C148.2, C149.2, C150.2, C151.2, C152.2, U$66.10 (GND), U$67.1 (1DIR), U$67.4 (GND), U$67.10 (GND), U$67.15 (GND), U$67.21 (GND), U$67.24 (2DIR), U$67.25 (2G), U$67.28 (GND), U$67.34 (GND), U$67.39 (GND), U$67.45 (GND), U$67.48 (1G), U$68.1 (1DIR), U$68.4 (GND), U$68.10 (GND), U$68.15 (GND), U$68.21 (GND), U$68.24 (2DIR), U$68.25 (2G), U$68.28 (GND), U$68.34 (GND), U$68.39 (GND), U$68.45 (GND), U$68.48 (1G), U$69.4 (GND), U$69.10 (GND), U$69.15 (GND), U$69.21 (GND), U$69.24 (2DIR), U$69.25 (2G), U$69.28 (GND), U$69.34 (GND), U$69.39 (GND), U$69.45 (GND), U$69.48 (1G), U$70.3 (GND), U$70.29 (GND), U$70.36 (GND); also elsewhere on the board
GREEN0$43: U$68.37 (1A7), U$70.13 (G0)
GREEN1$43: U$68.38 (1A6), U$70.14 (G1)
GREEN2$43: U$68.40 (1A5), U$70.15 (G2)
GREEN3$43: U$68.41 (1A4), U$70.16 (G3)
GREEN4$43: U$68.43 (1A3), U$70.17 (G4)
GREEN5$43: U$68.44 (1A2), U$70.18 (G5)
GREEN6$43: U$68.46 (1A1), U$70.19 (G6)
GREEN7$43: U$68.47 (1A0), U$70.20 (G7)
RED0$43: U$68.26 (2A7), U$70.5 (R0)
RED1$43: U$68.27 (2A6), U$70.6 (R1)
RED2$43: U$68.29 (2A5), U$70.7 (R2)
RED3$43: U$68.30 (2A4), U$70.8 (R3)
RED4$43: U$68.32 (2A3), U$70.9 (R4)
RED5$43: U$68.33 (2A2), U$70.10 (R5)
RED6$43: U$68.35 (2A1), U$70.11 (R6)
RED7$43: U$68.36 (2A0), U$70.12 (R7)
TSMX$43: U$66.8 (X-), U$70.39 (XL)
TSMY$43: U$66.9 (Y-), U$70.38 (YD)
TSPX$43: U$66.6 (X+), U$70.37 (XR)
TSPY$43: U$66.7 (Y+), U$70.40 (YU)
VREF$43: C145.1, U$66.13 (VREF)

Notes on the sheet:
LOW => B DATA TO A BUS
LCD 4.3" [MOD00041] (43)

Schematic: botball_v5.sch, sheet 39

Parts:
C153, C154, C155, C156, C157, C161, C162, C163: 0.1uF; 0402
C158, C159, C160: 10uF; 0603
D21, D22, D23, D24, D25, D26, D27, D28, D29, D30: PS04LTVA1; D0402
FB7, FB8: 120R 1A; 0402
IC4: TFP410; TQFP-64
J15: HDMIMICRO; 46765-001
L7, L8, L9, L10: DLP0NSN900HL2; 03025-DLP0NS
R96, R97, R98, R99, R100, R101, R103, R105: 10K; 0402
R102: 510R; 0402
R104: 4K7; 0402
R106: 200K; 0402
R107, R108, R109, R112: 1K5; 0402
R113, R115, R116, R117: 10R0; 0402
R114: DNP; 0402
RP8, RP9, RP10: 10R0; 741X16
U33: PCA9306; DCT-8(SSOP)

Connections:
5V_SCL$44: D29.P2, J15.17 (15), R112.2, U33.6 (SCL2)
5V_SDA$44: D30.P2, J15.18 (16), R109.2, U33.5 (SDA2)
17.VCC_1.8: C161.1, R99.2, R107.1, R108.1, U33.2 (VREF1); also elsewhere on the board
18.VCC_3.3: C155.1, C156.1, C157.1, C158.1, FB7.1, FB8.1, IC4.1 (VDD), IC4.12 (VDD), IC4.33 (VDD), R96.1, R98.1, R104.1, R105.2; also elsewhere on the board
21.VCC_5.0: C162.1, J15.19 (18), R106.1, R109.1, R112.1; also elsewhere on the board
45.GPIO1_5: R103.1; also elsewhere on the board
45.I2C1_SCL: R107.2, U33.3 (SCL1); also elsewhere on the board
45.I2C1_SDA: R108.2, U33.4 (SDA1); also elsewhere on the board
45.LCD_BIAS: R115.1; also elsewhere on the board
45.LCD_DD0: R113.1; also elsewhere on the board
45.LCD_DD1: RP8.16; also elsewhere on the board
45.LCD_DD2: RP8.15; also elsewhere on the board
45.LCD_DD3: RP8.14; also elsewhere on the board
45.LCD_DD4: RP8.13; also elsewhere on the board
45.LCD_DD5: RP8.12; also elsewhere on the board
45.LCD_DD6: RP8.10; also elsewhere on the board
45.LCD_DD7: RP8.9; also elsewhere on the board
45.LCD_DD8: RP9.16; also elsewhere on the board
45.LCD_DD9: RP9.15; also elsewhere on the board
45.LCD_DD10: RP9.14; also elsewhere on the board
45.LCD_DD11: RP9.13; also elsewhere on the board
45.LCD_DD12: RP9.12; also elsewhere on the board
45.LCD_DD13: RP9.11; also elsewhere on the board
45.LCD_DD14: RP9.10; also elsewhere on the board
45.LCD_DD15: RP9.9; also elsewhere on the board
45.LCD_DD16: RP10.16; also elsewhere on the board
45.LCD_DD17: RP10.15; also elsewhere on the board
45.LCD_DD18: RP10.14; also elsewhere on the board
45.LCD_DD19: RP10.13; also elsewhere on the board
45.LCD_DD20: RP10.12; also elsewhere on the board
45.LCD_DD21: RP10.11; also elsewhere on the board
45.LCD_DD22: RP10.10; also elsewhere on the board
45.LCD_DD23: RP10.9; also elsewhere on the board
45.LCD_HSYNC: R117.1; also elsewhere on the board
45.LCD_PCLK: RP8.11; also elsewhere on the board
45.LCD_VSYNC: R116.1; also elsewhere on the board
!PD$44: IC4.10 (!PD), R103.2
C+$44: D27.P2, J15.12 (10), L10.2
C-$44: D28.P2, J15.14 (12), L10.3
COMMON_SHIELD: D21.P1, D22.P1, D23.P1, D24.P1, D25.P1, D26.P1, D27.P1, D28.P1, D29.P1, D30.P1, J15.CON1 (20), J15.CON2 (21), J15.CON3 (22), J15.CON4 (23); also elsewhere on the board
D0+$44: D25.P2, J15.9 (7), L9.2
D0-$44: D26.P2, J15.11 (9), L9.3
D1+$44: D23.P2, J15.6 (4), L8.2
D1-$44: D24.P2, J15.8 (6), L8.3
D2+$44: D21.P2, J15.3 (1), L7.2
D2-$44: D22.P2, J15.5 (3), L7.3
DE$44: IC4.2 (DE), R115.2
DKEN$44: IC4.35 (DKEN), R105.1, R114.1
DVI_!RESET!$44: IC4.13 (ISEL/!RESET), R97.2
DVI_BSEL$44: IC4.15 (BSEL/SCL), R98.2
DVI_DSEL$44: IC4.14 (DSEL/SDA), R101.2
DVI_HTPLG$44: IC4.9 (HTPLG), R96.2
DVI_VREF$44: IC4.3 (VREF), R99.1, R100.1
GND: C153.2, C154.2, C155.2, C156.2, C157.2, C158.2, C159.2, C160.2, C161.2, C162.2, C163.2, IC4.16 (VSS), IC4.17 (VSS), IC4.20 (VSS), IC4.26 (VSS), IC4.32 (VSS), IC4.34 (RSVD2), IC4.48 (VSS), IC4.56 (IDCK-), IC4.64 (VSS), IC4.TP, J15.4 (2), J15.7 (5), J15.10 (8), J15.13 (11), J15.16 (17), R97.1, R100.2, R101.1, R114.2, U33.1 (GND); also elsewhere on the board
HSYNC$44: IC4.4 (HSYNC), R117.2
I2C_VREF2$44: R106.2, U33.7 (VREF2), U33.8 (EN)
IDCK+$44: IC4.57 (IDCK+), RP8.6
MSEN$44: IC4.11 (MSEN), R104.2
PD0$44: IC4.63 (PD0), R113.2
PD1$44: IC4.62 (PD1), RP8.1
PD2$44: IC4.61 (PD2), RP8.2
PD3$44: IC4.60 (PD3), RP8.3
PD4$44: IC4.59 (PD4), RP8.4
PD5$44: IC4.58 (PD5), RP8.5
PD6$44: IC4.55 (PD6), RP8.7
PD7$44: IC4.54 (PD7), RP8.8
PD8$44: IC4.53 (PD8), RP9.1
PD9$44: IC4.52 (PD9), RP9.2
PD10$44: IC4.51 (PD10), RP9.3
PD11$44: IC4.50 (PD11), RP9.4
PD12$44: IC4.47 (PD12), RP9.5
PD13$44: IC4.46 (PD13), RP9.6
PD14$44: IC4.45 (PD14), RP9.7
PD15$44: IC4.44 (PD15), RP9.8
PD16$44: IC4.43 (PD16), RP10.1
PD17$44: IC4.42 (PD17), RP10.2
PD18$44: IC4.41 (PD18), RP10.3
PD19$44: IC4.40 (PD19), RP10.4
PD20$44: IC4.39 (PD20), RP10.5
PD21$44: IC4.38 (PD21), RP10.6
PD22$44: IC4.37 (PD22), RP10.7
PD23$44: IC4.36 (PD23), RP10.8
PVDD$44: C153.1, C159.1, FB8.2, IC4.18 (VDD)
TFADJ$44: IC4.19 (TFADJ), R102.1
TVDD$44: C154.1, C160.1, C163.1, FB7.2, IC4.23 (VDD), IC4.29 (VDD), R102.2
TXC+$44: IC4.22 (TXC+), L10.1
TXC-$44: IC4.21 (TXC-), L10.4
TXD0+$44: IC4.25 (TXD0+), L9.1
TXD0-$44: IC4.24 (TXD0-), L9.4
TXD1+$44: IC4.28 (TXD1+), L8.1
TXD1-$44: IC4.27 (TXD1-), L8.4
TXD2+$44: IC4.31 (TXD2+), L7.1
TXD2-$44: IC4.30 (TXD2-), L7.4
VSYNC$44: IC4.5 (VSYNC), R116.2

Notes on the sheet:
HDMI [MOD00042] (44)

Schematic: botball_v5.sch, sheet 40

Parts:
C221, C225, C235: 4.7uF; 0603
C222: 22uF; 0805
C223: 0.1uF; 0201
C224, C226, C227, C228, C229, C230, C231, C232, C233: 10uF; 0603
C234: 4.7uF_50V; 1210
C236, C237: 2.2uF; 0402
D31: MBRA140T3G; SMAJ
FB10: 120R 6.0A; 0805
L11, L12, L13: 2.2uH; 1515
L14: 18uH; WE-PD2_4532
R119: 0R; 0201
R120: 180K; 0201
R121, R124: 100K; 0201
R125: 10K; 0201
U35: TPS65217D; QFN40P600X600X100-49

Connections:
21.VCC_5.0: C221.1, FB10.1; also elsewhere on the board
45.BACKLIGHT_N: U35.33 (ISINK2), U35.34 (ISINK1); also elsewhere on the board
45.BACKLIGHT_P: C234.1, D31.C, U35.38 (FB_WLED); also elsewhere on the board
45.I2C0_SCL: U35.28 (SCL); also elsewhere on the board
45.I2C0_SDA: U35.27 (SDA); also elsewhere on the board
45.PMIC_PGOOD: U35.26 (PGOOD); also elsewhere on the board
AIN7$45: U35.16 (MUX_OUT); also elsewhere on the board
BAT$45: U35.4 (BAT1), U35.5 (BAT2), U35.6 (BAT_SENSE)
BYPASS$45: C224.1, U35.47 (BYPASS)
DC_IN$45: C225.1, FB10.2, U35.10 (AC)
GND: C221.2, C222.2, C223.2, C224.2, C225.2, C226.2, C227.2, C228.2, C229.2, C230.2, C231.2, C232.2, C233.2, C234.2, C235.2, C236.2, C237.2, R120.1, R121.1, U35.30 (PGND), U35.41 (AGND), U35.49 (PPAD); also elsewhere on the board
INT_LDO$45: C223.1, U35.48 (INT_LDO)
ISET1$45: R120.2, U35.35 (ISET1)
ISET2$45: R121.2, U35.36 (ISET2)
LDO_PGOOD$45: U35.46 (LDO_PGOOD); also elsewhere on the board
L_L1$45: L11.1, U35.20 (L1)
L_L2$45: L12.1, U35.23 (L2)
L_L3$45: L13.1, U35.31 (L3)
L_L4$45: D31.A, L14.2, U35.37 (L4)
NMI$45: R119.2; also elsewhere on the board
PMIC_INT$45: R119.1, R125.1, U35.45 (!INT)
PMIC_PWR_EN$45: U35.9 (PWR_EN); also elsewhere on the board
PMIC_WAKEUP$45: R124.1, U35.13 (!WAKEUP); also elsewhere on the board
VDDS_DDR$45: C228.1, L11.2, U35.19 (VDCDC1); also elsewhere on the board
VDD_1V8$45: C232.1, U35.40 (LS1_OUT); also elsewhere on the board
VDD_3V3$45: C233.1, U35.43 (LS2_OUT); also elsewhere on the board
VDD_CORE$45: C230.1, L13.2, U35.29 (VDCDC3); also elsewhere on the board
VDD_MPU$45: C231.1, L12.2, U35.24 (VDCDC2); also elsewhere on the board
VLDO2$45: C236.1, U35.1 (VLDO2)
VRTC$45: C237.1, R124.2, R125.2, U35.3 (VLDO1), U35.18 (VIO); also elsewhere on the board
V_SYS$45: C222.1, C226.1, C227.1, C229.1, C235.1, L14.1, U35.2 (VINLDO), U35.7 (SYS1), U35.8 (SYS2), U35.21 (VIN_DCDC1), U35.22 (VIN_DCDC2), U35.32 (VIN_DCDC3), U35.39 (LS1_IN), U35.42 (LS2_IN)

Notes on the sheet:
PMIC TPS65217D [MOD00054] (45)

Schematic: botball_v5.sch, sheet 41

Parts:
C220, C252, C253, C254, C255, C256, C257, C258, C259, C260, C261, C262: 0.1uF; 0201
R122, R123, R134: 1K5; 0201
R131, R132, R135: 10K; 0201
R133: 240R0; 0201
R340, R342, R344: 100K; 0201
U34: AT24C01B-TH_B; TSSOP8
U$101: MT41K256M16; FBGA_96_10_14

Connections:
45.I2C0_SCL: R123.1, U34.6 (SCL); also elsewhere on the board
45.I2C0_SDA: R122.1, U34.5 (SDA); also elsewhere on the board
!DDR3_RESET$45: R134.2, U$101.T2 (!RESET); also elsewhere on the board
DDR_A0$45: U$101.N3 (A0); also elsewhere on the board
DDR_A1$45: U$101.P7 (A1); also elsewhere on the board
DDR_A2$45: U$101.P3 (A2); also elsewhere on the board
DDR_A3$45: U$101.N2 (A3); also elsewhere on the board
DDR_A4$45: U$101.P8 (A4); also elsewhere on the board
DDR_A5$45: U$101.P2 (A5); also elsewhere on the board
DDR_A6$45: U$101.R8 (A6); also elsewhere on the board
DDR_A7$45: U$101.R2 (A7); also elsewhere on the board
DDR_A8$45: U$101.T8 (A8); also elsewhere on the board
DDR_A9$45: U$101.R3 (A9); also elsewhere on the board
DDR_A10$45: U$101.L7 (A10); also elsewhere on the board
DDR_A11$45: U$101.R7 (A11); also elsewhere on the board
DDR_A12$45: U$101.N7 (A12); also elsewhere on the board
DDR_A13$45: U$101.T3 (A13); also elsewhere on the board
DDR_A14$45: U$101.T7 (A14); also elsewhere on the board
DDR_A15$45: U$101.M7 (A15); also elsewhere on the board
DDR_BA0$45: U$101.M2 (BA0); also elsewhere on the board
DDR_BA1$45: U$101.N8 (BA1); also elsewhere on the board
DDR_BA2$45: U$101.M3 (BA2); also elsewhere on the board
DDR_CASN$45: U$101.K3 (!CAS); also elsewhere on the board
DDR_CKE$45: R135.2, U$101.K9 (CKE); also elsewhere on the board
DDR_CK_N$45: U$101.K7 (!CK); also elsewhere on the board
DDR_CK_P$45: U$101.J7 (CK); also elsewhere on the board
DDR_CSN0$45: U$101.L2 (!CS); also elsewhere on the board
DDR_D0$45: U$101.E3 (DQ0); also elsewhere on the board
DDR_D1$45: U$101.F7 (DQ1); also elsewhere on the board
DDR_D2$45: U$101.F2 (DQ2); also elsewhere on the board
DDR_D3$45: U$101.F8 (DQ3); also elsewhere on the board
DDR_D4$45: U$101.H3 (DQ4); also elsewhere on the board
DDR_D5$45: U$101.H8 (DQ5); also elsewhere on the board
DDR_D6$45: U$101.G2 (DQ6); also elsewhere on the board
DDR_D7$45: U$101.H7 (DQ7); also elsewhere on the board
DDR_D8$45: U$101.D7 (DQ8); also elsewhere on the board
DDR_D9$45: U$101.C3 (DQ9); also elsewhere on the board
DDR_D10$45: U$101.C8 (DQ10); also elsewhere on the board
DDR_D11$45: U$101.C2 (DQ11); also elsewhere on the board
DDR_D12$45: U$101.A7 (DQ12); also elsewhere on the board
DDR_D13$45: U$101.A2 (DQ13); also elsewhere on the board
DDR_D14$45: U$101.B8 (DQ14); also elsewhere on the board
DDR_D15$45: U$101.A3 (DQ15); also elsewhere on the board
DDR_DQM0$45: U$101.E7 (LDM); also elsewhere on the board
DDR_DQM1$45: U$101.D3 (UDM); also elsewhere on the board
DDR_DQS0_N$45: U$101.G3 (!LDQS); also elsewhere on the board
DDR_DQS0_P$45: U$101.F3 (LDQS); also elsewhere on the board
DDR_DQS1_N$45: U$101.B7 (!UDQS); also elsewhere on the board
DDR_DQS1_P$45: U$101.C7 (UDQS); also elsewhere on the board
DDR_ODT$45: U$101.K1 (ODT); also elsewhere on the board
DDR_RASN$45: U$101.J3 (!RAS); also elsewhere on the board
DDR_VREF$45: C256.1, C257.1, R131.2, R132.1, U$101.H1 (VREF_DQ), U$101.M8 (VREF_CA); also elsewhere on the board
DDR_WEN$45: U$101.L3 (!WE); also elsewhere on the board
EE_A0$45: R340.2, U34.1 (A0)
EE_A1$45: R342.2, U34.2 (A1)
EE_A2$45: R344.2, U34.3 (A2)
GND: C220.2, C252.2, C253.2, C254.2, C255.2, C256.2, C257.2, C258.2, C259.2, C260.2, C261.2, C262.2, R132.2, R133.2, R135.1, R340.1, R342.1, R344.1, U34.4 (GND), U34.7 (WP), U$101.A9 (VSS), U$101.B1 (VSSQ), U$101.B3 (VSS), U$101.B9 (VSSQ), U$101.D1 (VSSQ), U$101.D8 (VSSQ), U$101.E1 (VSS), U$101.E2 (VSSQ), U$101.E8 (VSSQ), U$101.F9 (VSSQ), U$101.G1 (VSSQ), U$101.G8 (VSS), U$101.G9 (VSSQ), U$101.J2 (VSS), U$101.J8 (VSS), U$101.M1 (VSS), U$101.M9 (VSS), U$101.P1 (VSS), U$101.P9 (VSS), U$101.T1 (VSS), U$101.T9 (VSS); also elsewhere on the board
VDDS_DDR$45: C252.1, C253.1, C254.1, C255.1, C258.1, C259.1, C260.1, C261.1, C262.1, R131.1, R134.1, U$101.A1 (VDDQ), U$101.A8 (VDDQ), U$101.B2 (VDD), U$101.C1 (VDDQ), U$101.C9 (VDDQ), U$101.D2 (VDDQ), U$101.D9 (VDD), U$101.E9 (VDDQ), U$101.F1 (VDDQ), U$101.G7 (VDD), U$101.H2 (VDDQ), U$101.H9 (VDDQ), U$101.K2 (VDD), U$101.K8 (VDD), U$101.N1 (VDD), U$101.N9 (VDD), U$101.R1 (VDD), U$101.R9 (VDD); also elsewhere on the board
VDD_1V8$45: C220.1, R122.2, R123.2, U34.8 (VCC); also elsewhere on the board
ZQ$45: R133.1, U$101.L8 (ZQ)

Notes on the sheet:
Address: 0b0101_0A[2:0] = 0x50
EEPROM
Memory [MOD00054] (45)
DDR3

Schematic: botball_v5.sch, sheet 42

Parts:
C164, C165, C166, C167: 1.0uF; 0201
R129: 49R9; 0201
U$72: AM3354BZCZ80; BGA324C80P18X18
U$79, U$80, U$81, U$82: 100K; 741C083

Connections:
45.BACKLIGHT_ENABLE: U$72.V17 (GPMC_A11|GMII2_RXD0|RGMII2_RD0|RMII2_RX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); also elsewhere on the board
45.GPIO1_1: U$72.V7 (GPMC_AD1|MMC1_DAT1||||||GPIO1_1); also elsewhere on the board
45.GPIO1_2: U$72.R8 (GPMC_AD2|MMC1_DAT2||||||GPIO1_2); also elsewhere on the board
45.GPIO1_3: U$72.T8 (GPMC_AD3|MMC1_DAT3||||||GPIO1_3); also elsewhere on the board
45.GPIO1_4: U$72.U8 (GPMC_AD4|MMC1_DAT4||||||GPIO1_4); also elsewhere on the board
45.GPIO1_5: U$72.V8 (GPMC_AD5|MMC1_DAT5||||||GPIO1_5); also elsewhere on the board
45.GPIO1_16: U$72.R13 (GPMC_A0|GMII2_TXEN|RGMII2_TCTL|RMII2_TX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); also elsewhere on the board
45.GPIO1_20: U$72.R14 (GPMC_A4|GMII2_TXD1|RGMII2_TD1|RMII2_TXD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); also elsewhere on the board
45.GPIO1_21: U$72.V15 (GPMC_A5|GMII2_TXD0|RGMII2_TD0|RMII2_TXD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); also elsewhere on the board
45.GPIO1_22: U$72.U15 (GPMC_A6|GMII2_TXCLK|RGMII2_TCLK|MMC2_DA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); also elsewhere on the board
45.GPIO1_29: U$72.V6 (GPMC_CSN0|GPIO1_29); also elsewhere on the board
45.GPIO1_30: U$72.U9 (GPMC_CSN1|GPMC_CLK|MMC1_CLK|PRT1EDIO_DA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); also elsewhere on the board
45.GPIO1_31: U$72.V9 (GPMC_CSN2|GPMC_BE1N|MMC1_CMD|PR1_EDIO_D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); also elsewhere on the board
45.I2C0_SCL: U$72.C16 (I2C0_SCL|TIMER7|UART2_RTSN|ECAP1_IN_PWM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); also elsewhere on the board
45.I2C0_SDA: U$72.C17 (I2C0_SDA|TIMER4|UART2_CTSN|ECAP2_IN_PWM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); also elsewhere on the board
45.LCD_BIAS: U$72.R6 (LCD_AC_BIAS_EN|GPMC_A11||PR1_EDIO_DATA_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); also elsewhere on the board
45.LCD_DD0: U$72.R1 (LCD_DATA0|GPMC_A0||EHRPWM2A||PR1_PRU1_P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), U$80.P5; also elsewhere on the board
45.LCD_DD1: U$72.R2 (LCD_DATA1|GPMC_A1||EHRPWM2B||PR1_PRU1_P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), U$80.P7; also elsewhere on the board
45.LCD_DD2: U$72.R3 (LCD_DATA2|GPMC_A2||EHRPWM2_TRIPZONE_INP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), U$80.P6; also elsewhere on the board
45.LCD_DD3: U$72.R4 (LCD_DATA3|GPMC_A3||EHRPWM2_SYNCI_O||PR1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), U$80.P8; also elsewhere on the board
45.LCD_DD4: U$72.T1 (LCD_DATA4|GPMC_A4||EQEP2A_IN||PR1_PRU1_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), U$79.P5; also elsewhere on the board
45.LCD_DD5: U$72.T2 (LCD_DATA5|GPMC_A5||EQEP2B_IN||PR1_PRU1_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), U$79.P7; also elsewhere on the board
45.LCD_DD6: U$72.T3 (LCD_DATA6|GPMC_A6|PR1_EDIO_DATA_IN6|EQE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), U$79.P6; also elsewhere on the board
45.LCD_DD7: U$72.T4 (LCD_DATA7|GPMC_A7|PR1_EDIO_DATA_IN7|EQE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), U$81.P5; also elsewhere on the board
45.LCD_DD8: U$72.U1 (LCD_DATA8|GPMC_A12|EHRPWM1_TRIPZONE_INP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), U$79.P8; also elsewhere on the board
45.LCD_DD9: U$72.U2 (LCD_DATA9|GPMC_A13|EHRPWM1_SYNCI_O|MCAS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), U$81.P6; also elsewhere on the board
45.LCD_DD10: U$72.U3 (LCD_DATA10|GPMC_A14|EHRPWM1A|MCASP0_AXR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), U$81.P8; also elsewhere on the board
45.LCD_DD11: U$72.U4 (LCD_DATA11|GPMC_A15|EHRPWM1B|MCASP0_AHC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), U$82.P6; also elsewhere on the board
45.LCD_DD12: U$72.V2 (LCD_DATA12|GPMC_A16|EQEP1A_IN|MCASP0_AC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), U$81.P7; also elsewhere on the board
45.LCD_DD13: U$72.V3 (LCD_DATA13|GPMC_A17|EQEP1B_IN|MCASP0_FS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), U$82.P5; also elsewhere on the board
45.LCD_DD14: U$72.V4 (LCD_DATA14|GPMC_A18|EQEP1_INDEX|MCASP0_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), U$82.P7; also elsewhere on the board
45.LCD_DD15: U$72.T5 (LCD_DATA15|GPMC_A19|EQEP1_STROBE|MCASP0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), U$82.P8; also elsewhere on the board
45.LCD_DD16: U$72.U13 (GPMC_AD15|LCD_DATA16|MMC1_DAT7|MMC2_DAT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); also elsewhere on the board
45.LCD_DD17: U$72.V13 (GPMC_AD14|LCD_DATA17|MMC1_DAT6|MMC2_DAT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); also elsewhere on the board
45.LCD_DD18: U$72.R12 (GPMC_AD13|LCD_DATA18|MMC1_DAT5|MMC2_DAT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); also elsewhere on the board
45.LCD_DD19: U$72.T12 (GPMC_AD12|LCD_DATA19|MMC1_DAT4|MMC2_DAT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); also elsewhere on the board
45.LCD_DD20: U$72.U12 (GPMC_AD11|LCD_DATA20|MMC1_DAT3|MMC2_DAT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); also elsewhere on the board
45.LCD_DD21: U$72.T11 (GPMC_AD10|LCD_DATA21|MMC1_DAT2|MMC2_DAT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); also elsewhere on the board
45.LCD_DD22: U$72.T10 (GPMC_AD9|LCD_DATA22|MMC1_DAT1|MMC2_DAT5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); also elsewhere on the board
45.LCD_DD23: U$72.U10 (GPMC_AD8|LCD_DATA23|MMC1_DAT0|MMC2_DAT4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); also elsewhere on the board
45.LCD_HSYNC: U$72.R5 (LCD_HSYNC|GPMC_A9||PR1_EDIO_DATA_IN3|PR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); also elsewhere on the board
45.LCD_PCLK: U$72.V5 (LCD_PCLK|GPMC_A10||PR1_EDIO_DATA_IN4|PR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); also elsewhere on the board
45.LCD_VSYNC: U$72.U5 (LCD_VSYNC|GPMC_A8||PR1_EDIO_DATA_IN2|PR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); also elsewhere on the board
45.MMC2_CLK: U$72.V12 (GPMC_CLK|LCD_MEM_CLK|GPMC_WAIT1|MMC2_CL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); also elsewhere on the board
45.MMC2_CMD: U$72.T13 (GPMC_CSN3|MMC2_CMD|PR1_MDIO_DATA|GPIO2_0); also elsewhere on the board
45.MMC2_DAT0: U$72.V14 (GPMC_A1|GMII2_RXDV|RGMII2_RCTL|MMC2_DAT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); also elsewhere on the board
45.MMC2_DAT1: U$72.U14 (GPMC_A2|GMII2_TXD3|RGMII2_TD3|MMC2_DAT1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); also elsewhere on the board
45.MMC2_DAT2: U$72.T14 (GPMC_A3|GMII2_TXD2|RGMII2_TD2|MMC2_DAT2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); also elsewhere on the board
45.MMC2_DAT3: U$72.U18 (GPMC_BE1N|GMII2_COL|GPMC_CSN6|MMC2_DAT3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); also elsewhere on the board
!DDR3_RESET$45: U$72.G2 (DDR_RESETN); also elsewhere on the board
AIN7$45: U$72.C9 (AIN7); also elsewhere on the board
CAP_VBB_MPU$45: C164.1, U$72.C10 (CAP_VBB_MPU)
CAP_VDD_SRAM_CORE$45: C166.1, U$72.D9 (CAP_VDD_SRAM_CORE)
CAP_VDD_SRAM_MPU$45: C167.1, U$72.D11 (CAP_VDD_SRAM_MPU)
CAP_VSS_RTC$45: C165.1, U$72.D6 (CAP_VSS_RTC)
DDR_A0$45: U$72.F3 (DDR_A0); also elsewhere on the board
DDR_A1$45: U$72.H1 (DDR_A1); also elsewhere on the board
DDR_A2$45: U$72.E4 (DDR_A2); also elsewhere on the board
DDR_A3$45: U$72.C3 (DDR_A3); also elsewhere on the board
DDR_A4$45: U$72.C2 (DDR_A4); also elsewhere on the board
DDR_A5$45: U$72.B1 (DDR_A5); also elsewhere on the board
DDR_A6$45: U$72.D5 (DDR_A6); also elsewhere on the board
DDR_A7$45: U$72.E2 (DDR_A7); also elsewhere on the board
DDR_A8$45: U$72.D4 (DDR_A8); also elsewhere on the board
DDR_A9$45: U$72.C1 (DDR_A9); also elsewhere on the board
DDR_A10$45: U$72.F4 (DDR_A10); also elsewhere on the board
DDR_A11$45: U$72.F2 (DDR_A11); also elsewhere on the board
DDR_A12$45: U$72.E3 (DDR_A12); also elsewhere on the board
DDR_A13$45: U$72.H3 (DDR_A13); also elsewhere on the board
DDR_A14$45: U$72.H4 (DDR_A14); also elsewhere on the board
DDR_A15$45: U$72.D3 (DDR_A15); also elsewhere on the board
DDR_BA0$45: U$72.C4 (DDR_BA0); also elsewhere on the board
DDR_BA1$45: U$72.E1 (DDR_BA1); also elsewhere on the board
DDR_BA2$45: U$72.B3 (DDR_BA2); also elsewhere on the board
DDR_CASN$45: U$72.F1 (DDR_CASN); also elsewhere on the board
DDR_CKE$45: U$72.G3 (DDR_CKE); also elsewhere on the board
DDR_CK_N$45: U$72.D1 (DDR_CKN); also elsewhere on the board
DDR_CK_P$45: U$72.D2 (DDR_CK); also elsewhere on the board
DDR_CSN0$45: U$72.H2 (DDR_CSN0); also elsewhere on the board
DDR_D0$45: U$72.M3 (DDR_D0); also elsewhere on the board
DDR_D1$45: U$72.M4 (DDR_D1); also elsewhere on the board
DDR_D2$45: U$72.N1 (DDR_D2); also elsewhere on the board
DDR_D3$45: U$72.N2 (DDR_D3); also elsewhere on the board
DDR_D4$45: U$72.N3 (DDR_D4); also elsewhere on the board
DDR_D5$45: U$72.N4 (DDR_D5); also elsewhere on the board
DDR_D6$45: U$72.P3 (DDR_D6); also elsewhere on the board
DDR_D7$45: U$72.P4 (DDR_D7); also elsewhere on the board
DDR_D8$45: U$72.J1 (DDR_D8); also elsewhere on the board
DDR_D9$45: U$72.K1 (DDR_D9); also elsewhere on the board
DDR_D10$45: U$72.K2 (DDR_D10); also elsewhere on the board
DDR_D11$45: U$72.K3 (DDR_D11); also elsewhere on the board
DDR_D12$45: U$72.K4 (DDR_D12); also elsewhere on the board
DDR_D13$45: U$72.L3 (DDR_D13); also elsewhere on the board
DDR_D14$45: U$72.L4 (DDR_D14); also elsewhere on the board
DDR_D15$45: U$72.M1 (DDR_D15); also elsewhere on the board
DDR_DQM0$45: U$72.M2 (DDR_DQM0); also elsewhere on the board
DDR_DQM1$45: U$72.J2 (DDR_DQM1); also elsewhere on the board
DDR_DQS0_N$45: U$72.P2 (DDR_DQSN0); also elsewhere on the board
DDR_DQS0_P$45: U$72.P1 (DDR_DQS0); also elsewhere on the board
DDR_DQS1_N$45: U$72.L2 (DDR_DQSN1); also elsewhere on the board
DDR_DQS1_P$45: U$72.L1 (DDR_DQS1); also elsewhere on the board
DDR_ODT$45: U$72.G1 (DDR_ODT); also elsewhere on the board
DDR_RASN$45: U$72.G4 (DDR_RASN); also elsewhere on the board
DDR_VREF$45: U$72.J4 (DDR_VREF); also elsewhere on the board
DDR_VTP$45: R129.2, U$72.J3 (DDR_VTP)
DDR_WEN$45: U$72.B2 (DDR_WEN); also elsewhere on the board
GND: C164.2, C165.2, C166.2, C167.2, R129.1, U$79.P4, U$80.P4, U$81.P2, U$81.P3, U$81.P4, U$82.P1, U$82.P2, U$82.P4; also elsewhere on the board
VDD_1V8$45: U$79.P1, U$79.P2, U$79.P3, U$80.P1, U$80.P2, U$80.P3, U$81.P1, U$82.P3; also elsewhere on the board
VPP: U$72.M5 (VPP)

Notes on the sheet:
SYS_BOOT: 0b0100_0000 0b1111_0111
Boot @ 24MHz with RGMII (no-delay) and CLKOUT1
Order: MMC0, SPI0, UART0, USB0
AM335X(1) [MOD00054] (45)
Layout: Mixed nets for easier routing
Replace these shorts with wires once the design schematic is assembled

Schematic: botball_v5.sch, sheet 43

Parts:
C170, C171: 12pF; 0201
R110: DNP; 0603
R118: 0R; 0201
R128, R130: 1K5; 0201
U$72: AM3354BZCZ80; BGA324C80P18X18
Y4: 32.768kHz; 1206

Connections:
21.VCC_5.0: R110.2; also elsewhere on the board
22.MMC0_CLK: U$72.G17 (MMC0_CLK|GPMC_A24|UART3_CTSN|UART2_RXD|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); also elsewhere on the board
22.MMC0_CMD: U$72.G18 (MMC0_CMD|GPMC_A25|UART3_RTSN|UART2_TXD|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); also elsewhere on the board
22.MMC0_DAT0: U$72.G16 (MMC0_DAT0|GPMC_A23|UART5_RTSN|UART3_TXD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); also elsewhere on the board
22.MMC0_DAT1: U$72.G15 (MMC0_DAT1|GPMC_A22|UART5_CTSN|UART3_RXD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); also elsewhere on the board
22.MMC0_DAT2: U$72.F18 (MMC0_DAT2|GPMC_A21|UART4_RTSN|TIMER6|UA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); also elsewhere on the board
22.MMC0_DAT3: U$72.F17 (MMC0_DAT3|GPMC_A20|UART4_CTSN|TIMER5|UA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); also elsewhere on the board
45.I2C1_SCL: U$72.E17 (UART0_RTSN|UART4_TXD|DCAN1_RX|I2C1_SCL|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); also elsewhere on the board
45.I2C1_SDA: U$72.E18 (UART0_CTSN|UART4_RXD|DCAN1_TX|I2C1_SDA|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); also elsewhere on the board
45.I2C2_SCL: R128.1, U$72.D17 (UART1_RTSN|TIMER5|DCAN0_RX|I2C2_SCL|SPI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); also elsewhere on the board
45.I2C2_SDA: R130.1, U$72.D18 (UART1_CTSN|TIMER6|DCAN0_TX|I2C2_SDA|SPI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); also elsewhere on the board
45.MCASP0_ACLKX: U$72.A13 (MCASP0_ACLKX|EHRPWM0A||SPI1_SCLK|MMC0_S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); also elsewhere on the board
45.MCASP0_AXR0: U$72.D12 (MCASP0_AXR0|EHRPWM0_TRIPZONE_INPUT||SPI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); also elsewhere on the board
45.MCASP0_AXR1: U$72.D13 (MCASP0_AXR1|EQEP0_INDEX||MCASP1_AXR0|EM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); also elsewhere on the board
45.MCASP0_FSX: U$72.B13 (MCASP0_FSX|EHRPWM0B||SPI1_D0|MMC1_SDCD|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); also elsewhere on the board
45.PMIC_PGOOD: U$72.B15 (PWRONRSTN); also elsewhere on the board
45.SPI0_CLK: U$72.A17 (SPI0_SCLK|UART2_RXD|I2C2_SDA|EHRPWM0A|P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); also elsewhere on the board
45.SPI0_CS0: U$72.A16 (SPI0_CS0|MMC2_SDWP|I2C1_SCL|EHRPWM0_SYN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); also elsewhere on the board
45.SPI0_CS1: U$72.C15 (SPI0_CS1|UART3_RXD|ECAP1_IN_PWM1_OUT|MM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); also elsewhere on the board
45.SPI0_MISO: U$72.B17 (SPI0_D0|UART2_TXD|I2C2_SCL|EHRPWM0B|PR1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); also elsewhere on the board
45.SPI0_MOSI: U$72.B16 (SPI0_D1|MMC1_SDWP|I2C1_SDA|EHRPWM0_TRIP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); also elsewhere on the board
45.UART0_RX: U$72.E15 (UART0_RXD|SPI1_CS0|DCAN0_TX|I2C2_SDA|EC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); also elsewhere on the board
45.UART0_TX: U$72.E16 (UART0_TXD|SPI1_CS1|DCAN0_RX|I2C2_SCL|EC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); also elsewhere on the board
45.UART1_RX: U$72.D16 (UART1_RXD|MMC1_SDWP|DCAN1_TX|I2C1_SDA||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); also elsewhere on the board
45.UART1_TX: U$72.D15 (UART1_TXD|MMC2_SDWP|DCAN1_RX|I2C1_SCL||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); also elsewhere on the board
45.UART5_CTS: U$72.H17 (GMII1_CRS|RMII1_CRS_DV|SPI1_D0|I2C1_SDA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); also elsewhere on the board
45.UART5_RTS: U$72.J15 (GMII1_RXERR|RMII1_RXERR|SPI1_D1|I2C1_SC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); also elsewhere on the board
45.UART5_RX: U$72.H16 (GMII1_COL|RMII2_REFCLK|SPI1_SCLK|UART5_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); also elsewhere on the board
45.UART5_TX: U$72.J17 (GMII1_RXDV|LCD_MEMORY_CLK|RGMII1_RCTL|U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); also elsewhere on the board
45.USB_DEVICE_0_N: U$72.N18 (USB0_DM); also elsewhere on the board
45.USB_DEVICE_0_P: U$72.N17 (USB0_DP); also elsewhere on the board
45.USB_DEVICE_0_VBUS: U$72.P15 (USB0_VBUS); also elsewhere on the board
45.USB_HOST_1_N: U$72.R18 (USB1_DM); also elsewhere on the board
45.USB_HOST_1_P: U$72.R17 (USB1_DP); also elsewhere on the board
45.USB_HOST_1_PWREN: U$72.F15 (USB1_DRVVBUS); also elsewhere on the board
45.USB_HOST_1_VBUS: R110.1, U$72.T18 (USB1_VBUS); also elsewhere on the board
GND: U$72.P17 (USB1_ID); also elsewhere on the board
LDO_PGOOD$45: U$72.B5 (RTC_PWRONRSTN); also elsewhere on the board
PMIC_PWR_EN$45: U$72.C6 (PMIC_POWER_EN); also elsewhere on the board
RTC_XTAL_IN$45: C170.1, U$72.A6 (RTC_XTALIN), Y4.2
RTC_XTAL_OUT$45: C171.1, R118.2, U$72.A4 (RTC_XTALOUT)
RTC_XTAL_PRE_OUT$45: R118.1, Y4.1
VDD_1V8$45: R128.2, R130.2; also elsewhere on the board
VPP: U$72.M5 (VPP)
VSS_RTC$45: C170.2, C171.2; also elsewhere on the board

Notes on the sheet:
AM335X(2) [MOD00054] (45)
Just in case the VBUS detect doesn't work 0R this resistor to enable HOST

Notices in the files:
docs/botball_v5.brd:
Gumstix, Inc (c) 2015
